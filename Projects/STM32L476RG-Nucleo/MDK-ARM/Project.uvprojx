# Keil uVision project Project.uvprojx, settings and files
target Target_APP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32L476RG_OTA
  AfterMake: fromelf --bin !L --output Target_app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,Z_SOLO,STDC,ZLIB_CONST,Target_APP
  c misc: --C99
  c include: ..\Inc;..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include;..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc;..\..\..\Drivers\BSP\STM32L4xx_Nucleo;..\..\..\Drivers\BSP\Components\Common;..\..\..\Drivers\CMSIS\Include;..\zlib-1.2.11;..\..\..\common_lib;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32L4xx_Nucleo
    ../../../Drivers/BSP/STM32L4xx_Nucleo/: stm32l4xx_nucleo.c
  group Example/User
    ../Src/: main.c stm32l4xx_it.c drv_swo.c iap_if.c flash_if.c app_board.c stm32_uart.c ota_protocol.c drv_switch.c stm32_spi.c drv_watchdog.c stm32_Inrtc.c stm32_lptim.c timeServer.c drv_sx1278.c stm32_gpio_irq.c lora_pp.c low_power.c sensor_gpio.c adc.c rtc.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_gpio.c stm32l4xx_hal_cortex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rcc.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_lptim.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rtc_ex.c
    ./../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c
  group Example/MDK-ARM
    ./: startup_stm32l476xx.s
  group commom_lib
    ../../../common_lib/: usdl_bit.c usdl_calc.c usdl_conversion.c usdl_data.c usdl_io.c usdl_list.c usdl_mem.c usdl_string.c usdl_time.c usdl_tools.c usdl_buf.c
  group zlib
    ../zlib-1.2.11/: compress.c uncompr.c deflate.c inflate.c infback.c inftrees.c zutil.c adler32.c crc32.c trees.c inffast.c
target Target_Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: as above
  output: STM32L476RG_OTA
  AfterMake: fromelf --bin !L --output Target_app.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32L476xx,USE_HAL_DRIVER,USE_STM32L4XX_NUCLEO,Z_SOLO,STDC,ZLIB_CONST
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 4.3.0
